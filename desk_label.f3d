desk_label (Autodesk Fusion 360 design; units mm, degrees)
named bodies: "Blank", "Demo"